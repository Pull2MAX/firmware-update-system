# Keil uVision project bootloader_proj.uvprojx, settings and files
target link_to_aliyun (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: proj_for_app +hex
  AfterMake: D:\MyProgrammeSetUp\KEIL_V5.41\ARM\ARM_Compiler_5.06u7\bin\fromelf.exe --bin -o  ..\OBJ\linkToServer.bin  ..\OBJ\bootloader_proj.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F10X_MD
  c include: ..\USER;..\CMSIS\include;..\HW\include;..\LIB\Include
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group CMSIS
    ../CMSIS/src/: system_gd32f10x.c startup_gd32f10x_md.s
  group HW
    ../HW/src/: gd32f10x_it.c usart.c delay.c iic.c m24c02.c spi.c w25q64.c fmc.c 4g.c mqtt.c
  group LIB
    ../LIB/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_fmc.c
